/*SOC -*-c++-*-
**********************************************************************
**  _______  _______ _________ _______  _______ _________ _______   **
** (  ____ \(  ____ \\__   __/(  ___  )(  ____ )\__   __/(  ___  )  **
** | (    \/| (    \/   ) (   | (   ) || (    )|   ) (   | (   ) |  **
** | (_____ | |         | |   | |   | || (____)|   | |   | (___) |  **
** (_____  )| |         | |   | |   | ||  _____)   | |   |  ___  |  **
**       ) || |         | |   | |   | || (         | |   | (   ) |  **
** /\____) || (____/\___) (___| (___) || )         | |   | )   ( |  **
** \_______)(_______/\_______/(_______)|/          )_(   |/     \|  **
**                                                                  **
** (c) 2002,2003 Sciopta Systems GmbH, Litronic AG/ Schweiz         **
**                                                                  **
**********************************************************************
** ID: S07170BS4                                                    **
** +Revision: 1.2 +                                                **
** +Date: 2008/01/16 13:02:10 +                                     **
** shell: helper functions
**********************************************************************
EOC*/
#include <sciopta.h>
#include <ossys/libsc.h> /* dectoi */

int sh_hextoi(const char *s)
{
  int h = 0;
  char c;
  while( *s ){
    c = *s++;

    if ( c >= '0' && c <= '9' ){
      h <<= 4;
      h |= c-'0';
    } else if ( (c & 0xdf) >= 'A' && (c & 0xdf) <= 'F' ){
      h <<= 4;
      h |= (c & 0xdf) - 'A' + 10;
    } else {
      break;
    }
  }
  return h;
}

int sh_atoi(const char *s)
{
  if ( s[0] == '0' && (s[1] & 0xdf) == 'X' ){
    return sh_hextoi(&s[2]);
  }
  return dectoi(s);
}
