# IAR project Lcd_GFT035A320240Y.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCIncludePath2: ..\app; ..\modules; ..\board; ..\..\..\..\Drivers\include; ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\..\BoardSupport
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Lcd_IARDemo.srec
  ILINK.IlinkOutputFile: LCD_Demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: Cursor.c logo.c main.c
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Drivers
    ../modules/: drv_glcd.c i2c1_drv.c smb380_drv.c
    ../../../../Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_pinsel.c
    ../../../../BoardSupport/: sdram_k4s561632j.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/iar/: startup_LPC177x_8x.s
