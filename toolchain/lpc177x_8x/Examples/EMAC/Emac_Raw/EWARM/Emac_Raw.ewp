# IAR project Emac_Raw.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDiagSuppress: Pa050, Pa082, Pe111, Pe188, Pe186, Pe161
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\..\Drivers\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Adc_Dma.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\linker\ldscript_irom_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __RAM_MODE__
  ICCARM.CCIncludePath2: ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\startup\iar; ..\..\..\..\Drivers\include; ..\..\..\..\BoardSupport
  ILINK.IlinkIcfFile: ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC177x_8x\linker\ldscript_iram_iar.icf
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
  group Drivers
    ../../../../Drivers/source/: debug_frmwrk.c lpc177x_8x_clkpwr.c lpc177x_8x_emac.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c
  group Main
    ../: crc32.c Emac_Raw.c libnosys_gnu.c
  group Readme
    ../: abstract.txt
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/iar/: startup_LPC177x_8x.s
